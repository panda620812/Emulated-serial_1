# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Board\Inc;..\CMSIS\5.0.1\CMSIS\Include;..\CMSIS\5.0.1\CMSIS\RTOS2\Include;..\CMSIS-FreeRTOS\9.0.0\Source\include;..\RTE\RTOS;..\CMSIS-FreeRTOS\9.0.0\CMSIS\RTOS2\FreeRTOS\Include;..\CMSIS-FreeRTOS\9.0.0\Source\portable\RVDS\ARM_CM3;..\Device\StdPeriph_Driver\inc;..\RTE\Device\STM32F103ZE;..\RTE\_Target_1;..\FreeRTOS-Plus-FAT\include;..\FreeRTOS-Plus-FAT\portable\common;..\Board\Src;..\Board\Inc;..\MDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: main.c
    ../Board/Src/: board.c ausart.c gps_new.c
  group Board
    ../Board/Src/: GPIO_STM32F10x.c io_retarget.c
  group CMSIS-FreeRTOS
    ../CMSIS-FreeRTOS/9.0.0/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c
    ../CMSIS-FreeRTOS/9.0.0/CMSIS/RTOS2/FreeRTOS/Source/ARM/: clib_arm.c
  group FreeRTOS
    ../CMSIS-FreeRTOS/9.0.0/CMSIS/RTOS2/FreeRTOS/Source/: freertos_evr.c
    ../CMSIS-FreeRTOS/9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../CMSIS-FreeRTOS/9.0.0/Source/portable/MemMang/: heap_4.c
    ../CMSIS-FreeRTOS/9.0.0/Source/portable/RVDS/ARM_CM3/: port.c
    ../RTE/RTOS/: FreeRTOS_Tick_Config.c FreeRTOS_Tick_Config.h FreeRTOSConfig.h
  group Device
    ../Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
